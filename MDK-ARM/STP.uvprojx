# Keil uVision project STP.uvprojx, settings and files
target STP (ARM-ADS)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: STP
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c misc: --C99 --CPP11
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Drivers/MiddleDriver/Inc;..\Drivers\DataBase
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT5: ROM 0x8010000 size 0x70000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_tim.c stm32f4xx_hal_flash.c stm32f4xx_hal_gpio.c stm32f4xx_hal_can.c stm32f4xx_hal.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_i2c.c stm32f4xx_hal_rtc.c stm32f4xx_hal_i2c_ex.c
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Application/User
    ../Src/: main.c stm32f4xx_hal_msp.c can.c rtc.c usart.c stm32f4xx_it.c stm32f4xx_hal_timebase_TIM.c spi.c gpio.c i2c.c main.cpp opera.cpp opera_handle.cpp
  group Drivers/STP
    ../Drivers/MiddleDriver/Src/: STP_Server.cpp GR307.c Adafruit_NFCShield_I2C.cpp
software components: CMSIS:CORE 4.1.0
